# Keil uVision project Project.uvprojx, settings and files
target Project (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HSE_VALUE=8000000,USE_STDPERIPH_DRIVER
  c include: ..\..\USART;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../: stm32f4xx_it.c main.c
  group CMSIS
    ../: system_stm32f4xx.c
  group MDK-ARM
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c Sim800A.c Modbus.c basicFunc.c rtc_internal.c stm32f4xx_pwr.c stm32f4xx_rtc.c stm32f4xx_iwdg.c adc.c stm32f4xx_dma.c stm32f4xx_adc.c stm32f4xx_i2c.c i2c_eeprom.c
  group Library
    ../../../../Downloads/jsmn-master/jsmn-master/: jsmn.c jsmn.h
software components: CMSIS:CORE 5.0.0
